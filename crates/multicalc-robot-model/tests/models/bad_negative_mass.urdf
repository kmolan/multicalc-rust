Commit message: more changes

File: crates/multicalc-robot-model/tests/models/bad_negative_mass.urdf (robot description, URDF)
Before this commit: robot bad_zero_mass, 1 links, 0 joints
Links:
- link base_link: mass 0 -> -1
